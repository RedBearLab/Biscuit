# IAR project biscuit.ewp, settings and files
configuration CC2540 Biscuit UBL (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=TRUE; CC2540_MINIDK; USE_128_BIT_UUID; UUID_BASE_HEAD=0x3D,0x71; UUID_BASE_TAIL=0x1E,0x94,0x8D,0xF1,0x48,0x31,0x94,0xBA,0x75,0x4C,0x3E,0x50; FEATURE_UBL_MSD; OAD_KEEP_NV_PAGES; HAL_UART_ISR=1; HAL_UART_ISR_RX_MAX=250; HAL_UART; HAL_UART_DMA=0; ADV_ALWAYS_ON; MP_TEST; BISCUIT
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\Profiles\Roles; ..\..\Profiles\Biscuit; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2540 Biscuit UBL\Exe\Biscuit"
  XLINK.XclFile: new_cc254x_f256_ubl_msd.xcl
configuration CC2540 Biscuit CC Debugger (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=2048; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=TRUE; CC2540_MINIDK; USE_128_BIT_UUID; UUID_BASE_HEAD=0x3D,0x71; UUID_BASE_TAIL=0x1E,0x94,0x8D,0xF1,0x48,0x31,0x94,0xBA,0x75,0x4C,0x3E,0x50; HAL_UART_ISR=0; HAL_UART_ISR_RX_MAX=250; HAL_UART; HAL_UART_DMA=1; ADV_ALWAYS_ON; MP_TEST; BISCUIT
  XLINK.XclFile: ti_51ew_cc2540b.xcl
configuration CC2540 Biscuit-USB CC Debugger (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; CC2540_MINIDK; USE_128_BIT_UUID; UUID_BASE_HEAD=0x3D,0x71; UUID_BASE_TAIL=0x1E,0x94,0x8D,0xF1,0x48,0x31,0x94,0xBA,0x75,0x4C,0x3E,0x50; xHAL_UART_ISR=0; xHAL_UART_ISR_RX_MAX=250; xHAL_UART_DMA=1; ADV_ALWAYS_ON; MP_TEST; BISCUIT
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\target\CC2540USB; ..\..\..\..\Components\hal\target\CC2540USB\usb\library; ..\..\..\..\Components\hal\target\CC2540USB\usb\library\cc2540; ..\..\..\..\Components\hal\target\CC2540USB\usb\class_cdc; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\Profiles\Roles; ..\..\Profiles\Biscuit; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo
  XLINK.XclFile: ti_51ew_cc2540b.xcl
configuration CC2540 Biscuit-USB UBL (8051)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; CC2540_MINIDK; USE_128_BIT_UUID; UUID_BASE_HEAD=0x3D,0x71; UUID_BASE_TAIL=0x1E,0x94,0x8D,0xF1,0x48,0x31,0x94,0xBA,0x75,0x4C,0x3E,0x50; FEATURE_UBL_MSD; OAD_KEEP_NV_PAGES; xHAL_UART_ISR=0; xHAL_UART_ISR_RX_MAX=250; xHAL_UART_DMA=1; ADV_ALWAYS_ON; MP_TEST; BISCUIT
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2540 Biscuit-USB UBL\Exe\Biscuit"
  group APP
    ../Source/: biscuit.c biscuit.h Biscuit_Main.c eeprom.c eeprom.h i2c.c i2c.h OSAL_Biscuit.c uart.c uart.h
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/BLEMINI/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2540USB/Config
    ../../../../Components/hal/target/BLEMINI-USB/: hal_board_cfg.h
  group HAL/Target/CC2540USB/Drivers
    ../../../../Components/hal/target/CC2540USB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540USB/Includes
    ../../../../Components/hal/target/CC2540USB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2540USB/USB/class_cdc
    ../../../../Components/hal/target/CC2540USB/usb/class_cdc/: usb_cdc.h usb_cdc_descriptor.s51 usb_cdc_hooks.c usb_cdc_hooks.h usb_firmware_library_config.c usb_firmware_library_config.h usb_firmware_library_headers.h
  group HAL/Target/CC2540USB/USB/library
    ../../../../Components/hal/target/CC2540USB/usb/library/: usb_descriptor.h usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_framework.h usb_framework_structs.h usb_interrupt.h usb_reg.h usb_standard_requests.c usb_standard_requests.h usb_suspend.h
  group HAL/Target/CC2540USB/USB/library/cc2540
    ../../../../Components/hal/target/CC2540USB/usb/library/cc2540/: usb_board_cfg.h usb_interrupt.c usb_suspend.c
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/hci/: hci_c_data.h hci_c_event.h hci_controller.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/include/: ll.h ll_sleep.h phy.h phy_image.h
  group LIB
    ../../Libraries/CC2540DB/bin/: CC2540_ble_single_chip_peri.lib
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Biscuit/: biscuitservice.c biscuitservice.h
    ../../Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
